## embedded_software/barbie_firmware/sdkconfig.defaults
```kconfig
CONFIG_ESP_CONSOLE_USB_SERIAL_JTAG=y
CONFIG_FREERTOS_USE_TICKLESS_IDLE=1
CONFIG_FREERTOS_IDLE_TIME_BEFORE_SLEEP=3
```
